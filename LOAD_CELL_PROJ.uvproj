# Keil uVision project LOAD_CELL_PROJ.uvproj, settings and files
target Target 1 (MCS-51)
  device: MG82F6D32 Megawin
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF) XRAM (0-0xEFF) CLOCK(25000000)
  output: LOAD_CELL_PROJ +hex
  c flags: SizeSpeed=1
  c define: C51_COMPILER
  c include: .\Source;C:\Keil_v5\C51\INC
  asm include: C:\Keil_v5\C51\ASM
  group Source
    ./Source/: comm_prcs.c HX710.c iap.c main.c sys_init.c sys_tick.c uart0.c comm_prcs.h HX710.h iap.h main.h std_data_types.h sys_init.h sys_tick.h uart0.h I2c.c I2c.h
